# Keil uVision project AWS_MQTT_MutualAuth_Demo.Debug+VHT.uvprojx, settings and files
target Debug+VHT (6160000::V6.16::ARMCLANG)
  device: CMSDK_CM7_DP_VHT ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: AWS_MQTT_MutualAuth_Demo.Debug+VHT
  c flags: Optim=2 v6Lang=3 v6LangP=1 wLevel=3
  c define: MBEDTLS_CONFIG_FILE=\"aws_mbedtls_config.h\"
  c misc: -g -Wno-macro-redefined -Wno-pragma-pack -Wno-parentheses-equality
  c include: ./Interfaces;./config_files;./amazon-freertos/demos/include;./amazon-freertos/demos/network_manager;./amazon-freertos/demos/common/pkcs11_helpers;./amazon-freertos/libraries/logging/include;./amazon-freertos/libraries/abstractions/platform/include;./amazon-freertos/libraries/abstractions/platform/freertos/include;./amazon-freertos/libraries/abstractions/secure_sockets/include;./amazon-freertos/libraries/abstractions/transport/secure_sockets;./amazon-freertos/libraries/abstractions/wifi/include;./amazon-freertos/libraries/c_sdk/standard/common/include;./amazon-freertos/libraries/c_sdk/standard/common/include/private;./amazon-freertos/libraries/freertos_plus/standard/crypto/include;./amazon-freertos/libraries/freertos_plus/standard/tls/include;./Board/VHT_MPS2_Cortex-M7;./Interfaces/Socket;./config_files/Socket
  asm define: MBEDTLS_CONFIG_FILE=\"aws_mbedtls_config.h\"
  asm include: .\Board\VHT_MPS2_Cortex-M7;.\Interfaces;.\amazon-freertos\demos\common\pkcs11_helpers;.\amazon-freertos\demos\include;.\amazon-freertos\demos\network_manager;.\amazon-freertos\libraries\abstractions\platform\freertos\include\platform;.\amazon-freertos\libraries\abstractions\platform\include\platform;.\amazon-freertos\libraries\abstractions\platform\include\types;.\amazon-freertos\libraries\abstractions\secure_sockets\include;.\amazon-freertos\libraries\abstractions\transport\secure_sockets;.\amazon-freertos\libraries\abstractions\wifi\include;.\amazon-freertos\libraries\c_sdk\standard\common\include;.\amazon-freertos\libraries\c_sdk\standard\common\include\private;.\amazon-freertos\libraries\c_sdk\standard\common\include\types;.\amazon-freertos\libraries\freertos_plus\standard\crypto\include;.\amazon-freertos\libraries\freertos_plus\standard\tls\include;.\amazon-freertos\libraries\logging\include;.\config_files;.\config_files\Socket;./Interfaces;./config_files;./amazon-freertos/demos/include;./amazon-freertos/demos/network_manager;./amazon-freertos/demos/common/pkcs11_helpers;./amazon-freertos/libraries/logging/include;./amazon-freertos/libraries/abstractions/platform/include;./amazon-freertos/libraries/abstractions/platform/freertos/include;./amazon-freertos/libraries/abstractions/secure_sockets/include;./amazon-freertos/libraries/abstractions/transport/secure_sockets;./amazon-freertos/libraries/abstractions/wifi/include;./amazon-freertos/libraries/c_sdk/standard/common/include;./amazon-freertos/libraries/c_sdk/standard/common/include/private;./amazon-freertos/libraries/freertos_plus/standard/crypto/include;./amazon-freertos/libraries/freertos_plus/standard/tls/include;./Board/VHT_MPS2_Cortex-M7;./Interfaces/Socket;./config_files/Socket
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: RTE/Device/CMSDK_CM7_DP_VHT/ac6_arm.sct
  group Application:main
    ./: app_main.c
  group Application:config_files
    ./config_files/: aws_demo_config.h aws_mbedtls_config.h core_mqtt_config.h core_pkcs11_config.h iot_config.h mqtt_demo_mutual_auth_config.h
  group Application:demos_include
    ./amazon-freertos/demos/include/: aws_clientcredential.h aws_clientcredential_keys.h aws_demo.h aws_iot_metrics.h iot_config_common.h iot_demo_logging.h iot_demo_runner.h
  group Application:demos_demo_runner
    ./amazon-freertos/demos/demo_runner/: aws_demo.c iot_demo_runner.c iot_demo_freertos.c
  group Application:demos_coreMQTT
    ./amazon-freertos/demos/coreMQTT/: mqtt_demo_mutual_auth.c
  group Application:demos_network_manager
    ./amazon-freertos/demos/network_manager/: iot_network_manager_private.h aws_iot_network_manager.c
  group Application:demos_common_pkcs11_helpers
    ./amazon-freertos/demos/common/pkcs11_helpers/: pkcs11_helpers.h pkcs11_helpers.c
  group Application:libraries_abstractions_platform_include
    ./amazon-freertos/libraries/abstractions/platform/include/platform/: iot_clock.h iot_network.h iot_threads.h
    ./amazon-freertos/libraries/abstractions/platform/include/types/: iot_network_types.h iot_platform_types.h
  group Application:libraries_abstractions_platform_freertos
    ./amazon-freertos/libraries/abstractions/platform/freertos/include/platform/: iot_platform_types_freertos.h
    ./amazon-freertos/libraries/abstractions/platform/freertos/: iot_threads_freertos.c iot_clock_freertos.c
  group Application:libraries_abstractions_secure_sockets
    ./amazon-freertos/libraries/abstractions/secure_sockets/include/: iot_secure_sockets.h iot_secure_sockets_config_defaults.h
  group Application:libraries_abstractions_transport_secure_sockets
    ./amazon-freertos/libraries/abstractions/transport/secure_sockets/: transport_secure_sockets.h transport_secure_sockets.c
  group Application:libraries_abstractions_wifi
    ./amazon-freertos/libraries/abstractions/wifi/include/: iot_wifi.h
  group Application:libraries_c_sdk_standard_common_include
    ./amazon-freertos/libraries/c_sdk/standard/common/include/: iot_atomic.h iot_init.h iot_linear_containers.h iot_logging_setup.h iot_taskpool.h
    ./amazon-freertos/libraries/c_sdk/standard/common/include/private/: iot_default_root_certificates.h iot_error.h iot_lib_init.h iot_logging.h iot_static_memory.h iot_taskpool_internal.h
    ./amazon-freertos/libraries/c_sdk/standard/common/include/types/: iot_taskpool_types.h
  group Application:libraries_c_sdk_standard_common
    ./amazon-freertos/libraries/c_sdk/standard/common/: iot_device_metrics.c iot_init.c iot_static_memory_common.c
  group Application:libraries_c_sdk_standard_common_taskpool
    ./amazon-freertos/libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c iot_taskpool_static_memory.c
  group Application:libraries_logging
    ./amazon-freertos/libraries/logging/include/: iot_logging_task.h logging_levels.h logging_stack.h
    ./amazon-freertos/libraries/logging/: iot_logging.c iot_logging_task_dynamic_buffers.c
  group Application:libraries_freertos_plus_standard_crypto
    ./amazon-freertos/libraries/freertos_plus/standard/crypto/include/: iot_crypto.h
    ./amazon-freertos/libraries/freertos_plus/standard/crypto/src/: iot_crypto.c
  group Application:libraries_freertos_plus_standard_tls
    ./amazon-freertos/libraries/freertos_plus/standard/tls/include/: iot_tls.h
    ./amazon-freertos/libraries/freertos_plus/standard/tls/src/: iot_tls.c
  group Application:interfaces
    ./Interfaces/: threading_alt.h core_pkcs11_pal.c
  group Board
    ./Board/VHT_MPS2_Cortex-M7/: main.h main.c retarget_stdio.c vio_vht.c ETH_LAN91C111.h ETH_LAN91C111.c fvp_config.txt
  group Interface_AWS:config_files
    ./config_files/Socket/: aws_iot_network_config.h FreeRTOSIPConfig.h iot_secure_sockets_config.h
  group Interface_AWS:interfaces
    ./Interfaces/Socket/: network_startup.c iot_secure_sockets.c
  group Socket
    ./Socket/VSocket/: socket_startup.c iot_socket.c
software components: RTOS:Config 10.4.6, RTOS:Core 10.4.6, RTOS:Event Groups 10.4.6, RTOS:Heap 10.4.6, RTOS:Stream Buffer 10.4.6, RTOS:Timers 10.4.6, CMSIS Driver:Ethernet:Custom 1.0.0, CMSIS Driver:VIO:Custom 1.0.0, CMSIS:CORE 5.5.0, CMSIS:RTOS2:FreeRTOS 10.4.6, Security:mbed TLS 2.24.0, FreeRTOS:backoffAlgorithm 1.0.0, FreeRTOS:coreMQTT Agent 1.0.1, FreeRTOS:coreMQTT 1.1.0, FreeRTOS:corePKCS11 3.0.0, Security:PKCS11 3.0.0, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Board Support:Common 2.0.0, CMSIS Driver:USART 1.0.3, Device:Startup 1.1.0, IoT Utility:Socket:Custom 1.0.0
